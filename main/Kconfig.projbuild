## main/Kconfig.projbuild
```kconfig
config BUILD_SIMULATOR
	bool "Build simulator"
	help
		Build simulator using FreeRTOS posix simulator.
```
